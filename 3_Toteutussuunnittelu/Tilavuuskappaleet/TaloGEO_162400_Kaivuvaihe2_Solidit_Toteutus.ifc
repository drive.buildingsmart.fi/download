Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture], Option [ExcludedObjects: , , , , , , , , , , , , , , , , , , , ,]
Time: 2021-10-06T11:57:35
Author: teemu.tapaninen
Written by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016
Made in: Autodesk Civil 3D 2020 - English Build 13.2.890.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 6 11:57:35 2021 * Host: KUO00019 * Database: C:\Users\TEEMU~1.TAP\AppData\Local\Temp\ACAIFCTMP/EDM16524\aec_ifc_db * Database version: 5507 * Database creation date: Wed Oct 6 10:20:32 2021 * Schema: IFC2X3 * Model: DataRepository.AecIfc * Model creation date: Wed Oct 6 11:57:35 2021 * Header model: DataRepository.AecIfc_Header * Header model creation date: Wed Oct 6 11:57:35 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5649 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, TaloGEO
LongName: TaloGEO
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcSite
RefElevation: 0 m

# IfcBuilding, TaloGEO
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0

# IfcBuildingElementProxy (4)
In: TaloGEO
Name | Nimi | Volume
 | Kaivut vaihe 2 | 8536.63 | TaloGEO - InfraBIM: 162400
3 x  | Kohdistuskuutio | 1
